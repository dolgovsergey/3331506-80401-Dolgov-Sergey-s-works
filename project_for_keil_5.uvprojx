# Keil uVision project project_for_keil_5.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dummy
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB, STM32F10X_MD
  c misc: --c99
  c include: .\src\cmsis;.\src;.\src\mcu_support_package\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./src/main/: main.c
  group mcu_support_package
    ./src/mcu_support_package/arm/: startup_stm32f103xb.s
    ./src/mcu_support_package/: system_stm32f10x.c
